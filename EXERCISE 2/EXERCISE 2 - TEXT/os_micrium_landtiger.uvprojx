# Keil uVision project os_micrium_landtiger.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: os_micrium_landtiger
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Software\user\BSP;.\Software\user\configuration_os;.\Software\uC-Clk\Source;.\Software\uC-CPU\ARM-Cortex-M3;.\Software\uC-CPU\;.\Software\uC-CSP;.\Software\uC-CSP\LPC1768;.\Software\uC-LIB;.\Software\uC-LIB\Ports\ARM-Cortex-M3;.\Software\uCOS-III\Source;.\Software\uCOS-III\Ports\ARM-Cortex-M3\CSP;.\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic;C:\Users\franc\AppData\Local\Arm\Packs\ARM\CMSIS-Driver\2.4.0\SPI
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c includes.h password.h
    ./psw/: password.o
  group bsp
    ./Software/user/BSP/: bsp.c bsp.h bsp_os.c bsp_os.h
  group configuration_os
    ./Software/user/configuration_os/: app_hooks.c cpu_cfg.h csp_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h app_cfg.h
  group uC_Clk
    ./Software/uC-Clk/Source/: clk.h
  group uC_cpu
    ./Software/uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.s cpu_c.c
    ./Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC_csp
    ./Software/uC-CSP/: csp.c csp.h csp_types.h
    ./Software/uC-CSP/LPC1768/: csp_dev.h csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
  group uC_lib
    ./Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./Software/uC-LIB/Ports/ARM-Cortex-M3/: lib_mem_a.asm
  group uCOS_III
    ./Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ./Software/uCOS-III/Ports/ARM-Cortex-M3/CSP/: os_csp.c os_csp.h
    ./Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Board Support
    ./Board/adc/: IRQ_adc.c lib_adc.c adc.h
    ./Board/GLCD/: AsciiLib.c GLCD.c HzLib.c AsciiLib.h GLCD.h HzLib.h
    ./Board/joystick/: funct_joystick.c lib_joystick.c joystick.h
    ./Board/led/: funct_led.c lib_led.c led.h
    ./Board/timer/: IRQ_timer.c lib_timer.c timer.h
    ./Board/button_EXINT/: button.h IRQ_button.c lib_button.c
    ./Board/DMA/: funct_dma.c lib_dma.c
    ./Board/UART/: uart.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
